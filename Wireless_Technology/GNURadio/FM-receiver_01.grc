options:
  parameters:
    generate_options: qt_gui
    id: FMreceiver
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '4'
    quad_rate: 200e3
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: default
    samp_rate: '48000'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: '10'
    gain: '1'
    samp_rate: '2000000'
    type: fir_filter_ccf
    width: 50e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 2e6
    fc: 945e5
    fftsize: '1024'
    type: complex
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: 94.5e6
    gain0: '10'
    gain_mode0: 'True'
    if_gain0: '20'
    sample_rate: 2e6
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', audio_sink_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
